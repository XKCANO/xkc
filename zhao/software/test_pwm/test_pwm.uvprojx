# Keil uVision project test_pwm.uvprojx, settings and files
target test_pwm (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: PT32L076CBT7 PengpaiMicroelectronics
  pack: PAI-IC.PT32x076_DFP.1.1.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: 755PSMA5 v1 +hex
  c flags: Optim=1 oTime=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\CMSIS;.\lib;.\User
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ./User/: startup_PT32x076.s
  group USER
    ./User/: main.c PT32x076.h 755PSMA5_DEF.h 755PSMA5_System_PT32L076.c 755PSMA5_System_PT32L076.h 755PSMA5_Timer_PT32L076.c 755PSMA5_Timer_PT32L076.h 755PSMA5_Keyboard_PT32L076.c 755PSMA5_Keyboard_PT32L076.h 755PSMA5_Windows_PT32L076.c 755PSMA5_Windows_PT32L076.h 755PSMA5_Message_PT32L076.c 755PSMA5_Message_PT32L076.h
