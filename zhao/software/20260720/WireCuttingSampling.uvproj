# Keil uVision project WireCuttingSampling.uvproj, settings and files
target WireCuttingSampling (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: M0518LD2AE Nuvoton
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0x10FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: TIMER_Capture
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 oTime=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\CMSIS;.\User;.\Library\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x11000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --map --first='startup_M0518.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ./User/: startup_M0518.s
  group User
    ./User/: main.c WCS_M0518_DEF.h wcs_system_m0518.c wcs_system_m0518.h wcs_timer_m0518.c wcs_timer_m0518.h wcs_windows_m0518.c wcs_windows_m0518.h wcs_keyboard_m0518.c wcs_keyboard_m0518.h wcs_adc_m0518.c wcs_adc_m0518.h wcs_message_m0518.c wcs_message_m0518.h
    ../20260707/User/: M0518.h
