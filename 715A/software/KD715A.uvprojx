# Keil uVision project KD715A.uvprojx, settings and files
target KD715A (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: PT32L031K6T6 PengpaiMicroelectronics
  pack: PAI-IC.PT32X031_DFP.1.0.6
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: KD715A
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,PT32x031
  c include: .\CMSIS;.\Lib;.\User
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ./User/: startup_pt32x031.s
  group user
    ./User/: main.c KD715A_DEF.h KD715A_System_PT32L031.c KD715A_System_PT32L031.h KD715A_Timer_PT32L031.c KD715A_Timer_PT32L031.h KD715A_Keyboard_PT32L031.c KD715A_Keyboard_PT32L031.h KD715A_Windows_PT32L031.c KD715A_Windows_PT32L031.h KD715A_Batterylow_PT32L031.c KD715A_Batterylow_PT32L031.h KD715A_heat_PT32L031.c KD715A_heat_PT32L031.h KD715A_Message_PT32L031.c KD715A_Message_PT32L031.h ADC_PT32L031.c ADC_PT32L031.h
  group lib
    ./Lib/: FE_755LHA_EEPROM_PT32L031.h FE_755LHA_MAC.h FE_755LHA_PT32L031_CFG.h FE_755LHA_UART_PT32L031.h FE_IO.h FE_MATH.h FE_PHY_BC3602.h FE_semaphore.h FE_SPI_PT32L031.h FE_TIMER_PT32L031.h FE_755LHA_RevB_PT32L031_20250509 13dBm.lib
