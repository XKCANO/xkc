# Keil uVision project 755PSMA5L.uvprojx, settings and files
target 755PSMA5L (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: PT32L076CBT7 PengpaiMicroelectronics
  pack: PAI-IC.PT32x076_DFP.1.1.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: 755PSMA5L V1 +hex
  c flags: Optim=1 oTime=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\CMSIS;.\lib;.\User
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ./User/: startup_PT32x076.s
  group USER
    ./User/: main.c PT32x076.h 755PSMA5L_DEF.h 755PSMA5L_System_PT32L076.c 755PSMA5L_System_PT32L076.h 755PSMA5L_Timer_PT32L076.c 755PSMA5L_Timer_PT32L076.h 755PSMA5L_Keyboard_PT32L076.c 755PSMA5L_Keyboard_PT32L076.h 755PSMA5L_Windows_PT32L076.c 755PSMA5L_Windows_PT32L076.h 755PSMA5L_Message_PT32L076.c 755PSMA5L_Message_PT32L076.h
  group LIB
    ./lib/: FE_755PSMA5L_BATTERY_PT32L076.h FE_755PSMA5L_PT32L076_CFG.h FE_755PSMA5L_SMOKE_PT32L076.h FE_755PSMA5L_UART_PT32L076.h FE_IO.h FE_math.h FE_semaphore.h FE_SMOKE_EEPROM_PT32L076.h FE_SMOKE_TIMER_PT32L076.h FE_755PSMA5L_RevC_PT32L076_20250816.lib
