# Keil uVision project bc3602.uvprojx, settings and files
target 755LHA RF test (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: PT32L031K6T6 PengpaiMicroelectronics
  pack: PAI-IC.PT32X031_DFP.1.0.6
  cpu: CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: 755LHA RF test +hex
  c flags: Optim=1 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\User;.\cmsis
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ./User/: startup_pt32x031.s
  group User
    ./User/: main.c FE_755LHA_System_PT32L031.c FE_755LHA_Timer_PT32L031.c FE_755LHA_PT32L031_CFG.c FE_TIMER_PT32L031.c FE_IO.c FE_math.c FE_SPI_PT32L031.c FE_PHY_BC3602.c FE_755LHA_UART_PT32L031.c
