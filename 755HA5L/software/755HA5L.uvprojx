# Keil uVision project 755HA5L.uvprojx, settings and files
target 755HA5L (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: PT32L031K6T6 PengpaiMicroelectronics
  pack: PAI-IC.PT32X031_DFP.1.0.6
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: 755HA5L v05 +hex
  c flags: Optim=2 oTime=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\CMSIS;.\Lib;.\User
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ./User/: startup_pt32x031.s
  group USER
    ./User/: main.c pt32x031.h 755LHA_DEF.h 755LHA_System_PT32L031.c 755LHA_System_PT32L031.h 755LHA_Timer_PT32L031.c 755LHA_Timer_PT32L031.h 755LHA_Windows_PT32L031.c 755LHA_Windows_PT32L031.h 755LHA_Keyboard_PT32L031.c 755LHA_Keyboard_PT32L031.h 755LHA_heat_PT32L031.c 755LHA_heat_PT32L031.h 755LHA_Batterylow_PT32L031.c 755LHA_Batterylow_PT32L031.h 755LHA_RF_PT32L031.c 755LHA_RF_PT32L031.h 755LHA_Release_PT32L031.c 755LHA_Release_PT32L031.h 755LHA_Message_PT32L031.c 755LHA_Message_PT32L031.h ADC_PT32L031.c ADC_PT32L031.h
  group LIB
    ./Lib/: FE_755LHA_EEPROM_PT32L031.h FE_755LHA_MAC.h FE_755LHA_PT32L031_CFG.h FE_755LHA_UART_PT32L031.h FE_IO.h FE_MATH.h FE_PHY_BC3602.h FE_semaphore.h FE_SPI_PT32L031.h FE_TIMER_PT32L031.h FE_755LHA_RevB_PT32L031_20251202.lib
